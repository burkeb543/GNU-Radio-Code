options:
  parameters:
    author: Brian Burke
    description: Broadcast FM rx
    generate_options: qt_gui
    id: SDR_Pluto_1
    output_language: python
    title: Broadcast FM
  states: {}

blocks:
- name: audio_decim
  id: variable
  parameters:
    value: '8'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: rf_decim
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1920000'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    outputmsgname: value
    showports: 'False'
    start: '-100'
    step: '5'
    stop: '0'
    value: '-75'
  states: {}
- name: tuning
  id: variable_qtgui_chooser
  parameters:
    label: Station
    label0: RTE_2
    label1: RTE_1
    label2: RTE_Gael
    label3: RTE_Lyric
    label4: Spin_SW
    num_opts: '5'
    option0: '91000000'
    option1: '88000000'
    option2: '102100000'
    option3: '95200000'
    option4: '95600000'
    orient: Qt.QHBoxLayout
    type: int
    value: '91000000'
    widget: radio_buttons
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.3'
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: audio_decim
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: samp_rate/rf_decim
    deviation: deviation
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '5000000'
    bbdc: 'True'
    buffer_size: '16384'
    filter_source: '''Auto'''
    frequency: tuning
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    name: '"Channel "'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: rf_decim
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [iio_pluto_source_0, '0', qtgui_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
