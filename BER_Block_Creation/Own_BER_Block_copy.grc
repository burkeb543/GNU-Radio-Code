options:
  parameters:
    generate_options: qt_gui
    id: Own_BER_Block
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '2'
    type: byte
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '6'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "from gnuradio import gr\n\nimport numpy as np\n\nclass BitErrorRateBlock(gr.basic_block):\n    \"\"\"\n    Block that computes the bit error rate (BER) between two integer number inputs.\n    \"\"\"\n    def __init__(self):\n        gr.basic_block.__init__(\n            self,\n            name='BitErrorRateBlock',\n            in_sig=[np.int8, np.int8],\n            out_sig=[np.float32]\n        )\n        self._total_bits = 10\n        self._error_bits = 10\n\n    def general_work(self, input_items, output_items):\n\n        rx_sig, tx_sig = input_items[0], input_items[1]\n        length = 8\n        self._total_bits += length\n        self._error_bits += np.sum(np.logical_xor(tx_sig[:length], rx_sig[:length]))\n        output_items[0] = 65 + self._error_bits / self._total_bits\n        return output_items[0]\n\n\n\n\n"
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '128'
    min: '-128'
    name: '"Final_Output"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '128'
    min: '-128'
    name: '"Rx_sig"'
    type: byte
  states: {}
- name: qtgui_number_sink_0_0_0_0_0_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '128'
    min: '-128'
    name: '"Tx_sig"'
    type: byte
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_throttle_0, '0']
- [analog_const_source_x_0_0, '0', blocks_throttle_0_0, '0']
- [blocks_throttle_0, '0', epy_block_0, '0']
- [blocks_throttle_0, '0', qtgui_number_sink_0_0_0_0_0_1, '0']
- [blocks_throttle_0_0, '0', epy_block_0, '1']
- [blocks_throttle_0_0, '0', qtgui_number_sink_0_0_0_0_0_0, '0']
- [epy_block_0, '0', qtgui_number_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
