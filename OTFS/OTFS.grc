options:
  parameters:
    author: Abhishek Anand
    copyright: '2022'
    generate_options: qt_gui
    id: OTFS
    output_language: python
    title: OTFS Transceiver
  states: {}

blocks:
- name: fft_length
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'False'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\burke\OneDrive\Desktop\Test_Output.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_matrix_interleaver_0
  id: blocks_matrix_interleaver
  parameters:
    cols: '4'
    deint: 'False'
    rows: '4'
    type: complex
  states: {}
- name: blocks_matrix_interleaver_0_0
  id: blocks_matrix_interleaver
  parameters:
    cols: '4'
    deint: 'True'
    rows: '4'
    type: complex
  states: {}
- name: blocks_matrix_interleaver_0_0_0
  id: blocks_matrix_interleaver
  parameters:
    cols: '4'
    deint: 'True'
    rows: '4'
    type: complex
  states: {}
- name: blocks_matrix_interleaver_0_1
  id: blocks_matrix_interleaver
  parameters:
    cols: '4'
    deint: 'False'
    rows: '4'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: digital_qam_demod_0
  id: digital_qam_demod
  parameters:
    constellation_points: '16'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '1'
    timing_bw: 6.28/100.0
  states: {}
- name: digital_qam_mod_0
  id: digital_qam_mod
  parameters:
    constellation_points: '16'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '1'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '1'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    fft_size: '1'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1)
  states: {}
- name: fft_vxx_0_0_1
  id: fft_vxx
  parameters:
    fft_size: '1'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '1'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1)
  states: {}
- name: fft_vxx_0_1_0
  id: fft_vxx
  parameters:
    fft_size: '1'
    forward: 'False'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1)
  states: {}
- name: note_0
  id: note
  parameters:
    note: Transmitter section
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Receiver section
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32'
    name: Rx_spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32'
    name: Tx_spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: Transmitted signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: Recieved signal
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:50001
    key: '0'
    timeout: '100'
    type: float
  states: {}

connections:
- [analog_random_source_x_0, '0', blocks_throttle_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_1_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_1, '0']
- [blocks_float_to_complex_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_matrix_interleaver_0, '0', fft_vxx_0, '0']
- [blocks_matrix_interleaver_0_0, '0', fft_vxx_0_0, '0']
- [blocks_matrix_interleaver_0_0_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_matrix_interleaver_0_1, '0', fft_vxx_0_0_1, '0']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_1, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_1_0, '0', blocks_float_to_complex_0, '1']
- [blocks_stream_to_vector_0, '0', blocks_matrix_interleaver_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0_0, '0']
- [blocks_throttle_0, '0', digital_qam_mod_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_complex_to_float_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_vector_to_stream_0_0, '0', digital_qam_demod_0, '0']
- [digital_qam_demod_0, '0', blocks_file_sink_0, '0']
- [digital_qam_mod_0, '0', blocks_stream_to_vector_0, '0']
- [digital_qam_mod_0, '0', qtgui_freq_sink_x_2, '0']
- [digital_qam_mod_0, '0', qtgui_time_sink_x_1, '0']
- [fft_vxx_0, '0', blocks_matrix_interleaver_0_0, '0']
- [fft_vxx_0_0, '0', fft_vxx_0_1, '0']
- [fft_vxx_0_0_0, '0', fft_vxx_0_1_0, '0']
- [fft_vxx_0_0_1, '0', blocks_matrix_interleaver_0_0_0, '0']
- [fft_vxx_0_1, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_1_0, '0', blocks_matrix_interleaver_0_1, '0']
- [zeromq_sub_source_0, '0', blocks_multiply_xx_0_0, '1']
- [zeromq_sub_source_0, '0', blocks_multiply_xx_1_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
